# Dependencies required to populate the partitioned full image.
DEPENDS += " \
    rpi-bootloader-files \
"