#FILESEXTRAPATHS:prepend := "${THISDIR}/linux-intel:"
#SRC_URI += "file://defconfig"