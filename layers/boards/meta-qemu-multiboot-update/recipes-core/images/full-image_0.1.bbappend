# Dependencies required to populate the partitioned full image.
DEPENDS += " \
    efi-boot-image \
"